# Keil uVision project oven.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: oven
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Src
    ./: hardware.c main.c shared_data.c
  group Tasks
    ./: battery_task.c display_task.c door_task.c temperature_task.c battery_task.h display_task.h door_task.h temperature_task.h
  group Drivers
    ./: sensors.h utils.h sensors.c utils.c
  group Headers
    ./: tm4c.h shared_data.h hardware.h
software components: CMSIS:CORE 6.1.0, RTOS:Config 11.1.0, RTOS:Core 11.1.0, RTOS:Heap 11.1.0, RTOS:Timers 11.1.0, Device:Startup 1.0.1
