# Keil uVision project Oven.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Oven
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: adc_control.c adc_control.h battery_task.c battery_task.h buzzer_task.c buzzer_task.h door_task.c door_task.h gpio_init.c gpio_init.h hardware_init.c hardware_init.h lcd.c lcd.h lcd_task.c lcd_task.h main.c pwm_control.c pwm_control.h README.md temperature_task.c temperature_task.h tm4c123gh6pm.h
software components: CMSIS:CORE 6.1.1, RTOS:Config 11.2.0, RTOS:Core 11.2.0, RTOS:Heap 11.2.0, RTOS:Timers 11.2.0, Device:Startup 1.0.1
